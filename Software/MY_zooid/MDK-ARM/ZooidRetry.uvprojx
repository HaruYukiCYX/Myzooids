# Keil uVision project ZooidRetry.uvprojx, settings and files
target ZooidRetry (ARM-GNU)
  device: STM32F051C8Ux STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.1
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: ZooidRetry
  group Application/MDK-ARM
    ../STM32Cube_FW_F0_V1.11.0/Drivers/CMSIS/Device/ST/STM32F0xx/Source/Templates/gcc/: startup_stm32f051x8.s
  group Application/User
    ../Src/: main.c functions.c led.c motors.c RingBuffer.c stm32f0xx_hal_msp.c stm32f0xx_it.c stm32f0xx_lp_modes.c utilities.c colors.c usart.c
    ./: communication.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal.c stm32f0xx_hal_cortex.c stm32f0xx_hal_dma.c stm32f0xx_hal_gpio.c stm32f0xx_hal_pcd.c stm32f0xx_hal_pcd_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_spi.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_adc.c stm32f0xx_hal_pwr.c stm32f0xx_hal_i2c.c stm32f0xx_hal_spi_ex.c stm32f0xx_hal_adc_ex.c stm32f0xx_ll_usart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
    ./: syscall.c
software components: CMSIS:CORE 4.3.0
